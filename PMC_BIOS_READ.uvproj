# Keil uVision project PMC_BIOS_READ.uvproj, settings and files
target PMC_BIOS_READ (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F100VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: PMC_BIOS_READ
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD_VL, USE_STDPERIPH_DRIVER
  c include: .\lib;.\lib\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StdPeriph_Driver
    lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c
  group CMSIS
    lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    lib/CMSIS/CM3/CoreSupport/: core_cm3.c
  group MDK-ARM
    lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md_vl.s
  group User
    ./: main.c stm32f10x_it.c delayNS.c loopback.c retarget.c
  group STM32vldiscovery
    ./: STM32vldiscovery.c
